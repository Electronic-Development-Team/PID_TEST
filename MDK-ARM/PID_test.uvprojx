# Keil uVision project PID_test.uvprojx, settings and files
target PID_test (ARM-ADS)
  device: STM32F103C8 ARM
  output: PID_test
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;.cmsis/include;../MDK-ARM/RTE/_PID_test;../Users
  group ../USERS
    ../Users/: lcd_fonts.c lcd_image.c lcd_spi_200.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/MDK-ARM
    ../MDK-ARM/: startup_stm32f103xb.s
